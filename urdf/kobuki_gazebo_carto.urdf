Commit message: eddited .lua config

File: urdf/kobuki_gazebo_carto.urdf (robot description, URDF)
Before this commit: robot kobuki_standalone, 10 links, 9 joints
Links:
- removed link gyro_link
- added link imu_link, mass 0.001
Joints:
- joint gyro_joint: child gyro_link -> imu_link
